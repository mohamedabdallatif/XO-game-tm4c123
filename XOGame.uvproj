# Keil uVision project XOGame.uvproj, settings and files
target SpaceInvaders (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: XoGame +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s random.s XoGame.c
  group drivers
    ./drivers/: gpio_driver.c interrupt.c Timer2.c Nokia5110.c TExaS.c UART.c Leds.c
  group headers
    ./headers/: check_winner.h gpio_driver.h tm4c123gh6pm.h Timer2.h interrupt.h Run.h TExaS.h UART.h Leds.h
  group logic
    ./logic/: check_winner.c Run.c
